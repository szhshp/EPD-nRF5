# Keil uVision project DFU-nRF51.uvprojx, settings and files
target nrf51822_xxaa_s130 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bl_nrf51822_xxaa_s130 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 __STACK_SIZE=1600 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_SD_BLE_API_VERSION=2 S130 BOARD_PCA10028 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51422 NRF51 NRF_DFU_SETTINGS_VERSION=1
  c include: ..\SDK\12.3.0_d7731ad\dfu;..\SDK\12.3.0_d7731ad\components;..\SDK\12.3.0_d7731ad\components\ble\common;..\SDK\12.3.0_d7731ad\components\boards;..\SDK\12.3.0_d7731ad\components\drivers_nrf\clock;..\SDK\12.3.0_d7731ad\components\drivers_nrf\common;..\SDK\12.3.0_d7731ad\components\drivers_nrf\delay;..\SDK\12.3.0_d7731ad\components\drivers_nrf\hal;..\SDK\12.3.0_d7731ad\components\drivers_nrf\rng;..\SDK\12.3.0_d7731ad\components\libraries\bootloader;..\SDK\12.3.0_d7731ad\components\libraries\bootloader\ble_dfu;..\SDK\12.3.0_d7731ad\components\libraries\bootloader\dfu;..\SDK\12.3.0_d7731ad\components\libraries\crc32;..\SDK\12.3.0_d7731ad\components\libraries\crypto;..\SDK\12.3.0_d7731ad\components\libraries\ecc;..\SDK\12.3.0_d7731ad\components\libraries\experimental_section_vars;..\SDK\12.3.0_d7731ad\components\libraries\fstorage;..\SDK\12.3.0_d7731ad\components\libraries\hci;..\SDK\12.3.0_d7731ad\components\libraries\log;..\SDK\12.3.0_d7731ad\components\libraries\log\src;..\SDK\12.3.0_d7731ad\components\libraries\queue;..\SDK\12.3.0_d7731ad\components\libraries\scheduler;..\SDK\12.3.0_d7731ad\components\libraries\sha256;..\SDK\12.3.0_d7731ad\components\libraries\svc;..\SDK\12.3.0_d7731ad\components\libraries\timer;..\SDK\12.3.0_d7731ad\components\libraries\util;..\SDK\12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers\nrf51;..\SDK\12.3.0_d7731ad\components\toolchain;..\SDK\12.3.0_d7731ad\components\toolchain\cmsis\include;..\SDK\12.3.0_d7731ad\external\micro-ecc\micro-ecc;..\SDK\12.3.0_d7731ad\external\nano-pb
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DBOARD_PCA10028,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF51422,-DNRF51,-DNRF_DFU_SETTINGS_VERSION=1
  asm include: ..\SDK\12.3.0_d7731ad\dfu;..\SDK\12.3.0_d7731ad\components;..\SDK\12.3.0_d7731ad\components\ble\common;..\SDK\12.3.0_d7731ad\components\boards;..\SDK\12.3.0_d7731ad\components\drivers_nrf\clock;..\SDK\12.3.0_d7731ad\components\drivers_nrf\common;..\SDK\12.3.0_d7731ad\components\drivers_nrf\delay;..\SDK\12.3.0_d7731ad\components\drivers_nrf\hal;..\SDK\12.3.0_d7731ad\components\drivers_nrf\rng;..\SDK\12.3.0_d7731ad\components\libraries\bootloader;..\SDK\12.3.0_d7731ad\components\libraries\bootloader\ble_dfu;..\SDK\12.3.0_d7731ad\components\libraries\bootloader\dfu;..\SDK\12.3.0_d7731ad\components\libraries\crc32;..\SDK\12.3.0_d7731ad\components\libraries\crypto;..\SDK\12.3.0_d7731ad\components\libraries\ecc;..\SDK\12.3.0_d7731ad\components\libraries\experimental_section_vars;..\SDK\12.3.0_d7731ad\components\libraries\fstorage;..\SDK\12.3.0_d7731ad\components\libraries\hci;..\SDK\12.3.0_d7731ad\components\libraries\log;..\SDK\12.3.0_d7731ad\components\libraries\log\src;..\SDK\12.3.0_d7731ad\components\libraries\queue;..\SDK\12.3.0_d7731ad\components\libraries\scheduler;..\SDK\12.3.0_d7731ad\components\libraries\sha256;..\SDK\12.3.0_d7731ad\components\libraries\svc;..\SDK\12.3.0_d7731ad\components\libraries\timer;..\SDK\12.3.0_d7731ad\components\libraries\util;..\SDK\12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers;..\SDK\12.3.0_d7731ad\components\softdevice\s130\headers\nrf51;..\SDK\12.3.0_d7731ad\components\toolchain;..\SDK\12.3.0_d7731ad\external\micro-ecc\micro-ecc;..\SDK\12.3.0_d7731ad\external\nano-pb;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x3ac00 size 0x5000
  memory RVCT9: RAM 0x200025e0 size 0x1a20
  group Application
    ../SDK/12.3.0_d7731ad/dfu/: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c main.c sdk_config.h
  group Board Definition
    ../SDK/12.3.0_d7731ad/components/boards/: boards.c
  group nRF_BLE
    ../SDK/12.3.0_d7731ad/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../SDK/12.3.0_d7731ad/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../SDK/12.3.0_d7731ad/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
    ../SDK/12.3.0_d7731ad/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../SDK/12.3.0_d7731ad/components/drivers_nrf/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../SDK/12.3.0_d7731ad/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../SDK/12.3.0_d7731ad/components/libraries/scheduler/: app_scheduler.c
    ../SDK/12.3.0_d7731ad/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../SDK/12.3.0_d7731ad/components/libraries/crc32/: crc32.c
    ../SDK/12.3.0_d7731ad/components/libraries/ecc/: ecc.c
    ../SDK/12.3.0_d7731ad/components/libraries/fstorage/: fstorage.c
    ../SDK/12.3.0_d7731ad/components/libraries/hci/: hci_mem_pool.c
    ../SDK/12.3.0_d7731ad/components/libraries/crypto/: nrf_crypto.c
    ../SDK/12.3.0_d7731ad/components/libraries/queue/: nrf_queue.c
    ../SDK/12.3.0_d7731ad/components/libraries/sha256/: sha256.c
  group nRF_SoftDevice
    ../SDK/12.3.0_d7731ad/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_micro_ecc
    ../SDK/12.3.0_d7731ad/external/micro-ecc/nrf51_keil/armgcc/: micro_ecc_lib_nrf51.lib
  group nano-pb
    ../SDK/12.3.0_d7731ad/external/nano-pb/: pb_common.c pb_decode.c
  group Startup
    ../SDK/12.3.0_d7731ad/components/toolchain/arm/: arm_startup_nrf51.s
    ../SDK/12.3.0_d7731ad/components/toolchain/: system_nrf51.c
